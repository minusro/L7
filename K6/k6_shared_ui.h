// k6_shared_ui.h — the primitives, 3x5 font and tag, lifted from the
// N9-era app (keep in step). Included by k6_ui.cpp only.
#pragma once
static constexpr int PX = 2;

// ---- Primitives -----------------------------------------------------------

static void rct(int x, int y, int w, int h, uint16_t c) {
  if (w > 0 && h > 0) board.tft().fillRect(x, y, w, h, c);
}

static void frm(int x, int y, int w, int h, uint16_t c) {
  rct(x, y, w, PX, c); rct(x, y + h - PX, w, PX, c);
  rct(x, y, PX, h, c); rct(x + w - PX, y, PX, h, c);
}

static int rnd(float f) { return (int)(f + 0.5f); }

// ---- The 3x5 font (ui_font.cpp's glyphs, upper case + digits + signs) -----

struct Glyph { char c; const char *rows[5]; };
static const Glyph GLYPHS[] = {
    {' ', {"..", "..", "..", "..", ".."}},
    {'.', {".", ".", ".", ".", "#"}},
    {':', {".", "#", ".", "#", "."}},
    {'/', {"..#", "..#", ".#.", "#..", "#.."}},
    {'*', {"...", "#.#", ".#.", "#.#", "..."}},
    {'-', {"...", "...", "###", "...", "..."}},
    {'+', {"...", ".#.", "###", ".#.", "..."}},
    {'#', {".#.#", "####", ".#.#", "####", "#.#."}},
    {'\xA9', {".#####.", "#.###.#", "#.#...#", "#.###.#", ".#####."}},
    {'<', {"...#", "..##", ".###", "..##", "...#"}},
    {'>', {"#...", "##..", "###.", "##..", "#..."}},
    {'0', {"###", "#.#", "#.#", "#.#", "###"}},
    {'1', {".#.", "##.", ".#.", ".#.", "###"}},
    {'2', {"###", "..#", "###", "#..", "###"}},
    {'3', {"###", "..#", "###", "..#", "###"}},
    {'4', {"#.#", "#.#", "###", "..#", "..#"}},
    {'5', {"###", "#..", "###", "..#", "###"}},
    {'6', {"###", "#..", "###", "#.#", "###"}},
    {'7', {"###", "..#", "..#", "..#", "..#"}},
    {'8', {"###", "#.#", "###", "#.#", "###"}},
    {'9', {"###", "#.#", "###", "..#", "###"}},
    {'A', {".#.", "#.#", "###", "#.#", "#.#"}},
    {'B', {"##.", "#.#", "##.", "#.#", "##."}},
    {'C', {".##", "#..", "#..", "#..", ".##"}},
    {'D', {"##.", "#.#", "#.#", "#.#", "##."}},
    {'E', {"###", "#..", "##.", "#..", "###"}},
    {'F', {"###", "#..", "##.", "#..", "#.."}},
    {'G', {".##", "#..", "#.#", "#.#", ".##"}},
    {'H', {"#.#", "#.#", "###", "#.#", "#.#"}},
    {'I', {"###", ".#.", ".#.", ".#.", "###"}},
    {'J', {"..#", "..#", "..#", "#.#", ".#."}},
    {'K', {"#.#", "#.#", "##.", "#.#", "#.#"}},
    {'L', {"#..", "#..", "#..", "#..", "###"}},
    {'M', {"#...#", "##.##", "#.#.#", "#...#", "#...#"}},
    {'N', {"#..#", "##.#", "#.##", "#..#", "#..#"}},
    {'O', {".#.", "#.#", "#.#", "#.#", ".#."}},
    {'P', {"##.", "#.#", "##.", "#..", "#.."}},
    {'Q', {".#.", "#.#", "#.#", "##.", ".##"}},
    {'R', {"##.", "#.#", "##.", "#.#", "#.#"}},
    {'S', {"###", "#..", "###", "..#", "###"}},
    {'T', {"###", ".#.", ".#.", ".#.", ".#."}},
    {'U', {"#.#", "#.#", "#.#", "#.#", "###"}},
    {'V', {"#.#", "#.#", "#.#", "#.#", ".#."}},
    {'W', {"#...#", "#...#", "#.#.#", "##.##", "#...#"}},
    {'X', {"#.#", "#.#", ".#.", "#.#", "#.#"}},
    {'Y', {"#.#", "#.#", ".#.", ".#.", ".#."}},
    {'Z', {"###", "..#", ".#.", "#..", "###"}},
};

static const Glyph *glyph(char c) {
  for (const auto &g : GLYPHS) if (g.c == c) return &g;
  return nullptr;
}

static int txtW(const char *s) {
  int b = 0;
  for (const char *p = s; *p; p++) if (const Glyph *g = glyph(*p)) b += strlen(g->rows[0]) + 1;
  return b ? b * PX - PX : 0;
}

static void txt(int x, int y, const char *s, uint16_t ink) {
  int bx = 0;
  for (const char *p = s; *p; p++) {
    const Glyph *g = glyph(*p); if (!g) continue;
    int gw = strlen(g->rows[0]);
    for (int r = 0; r < 5; r++)
      for (int c = 0; c < gw; c++)
        if (g->rows[r][c] == '#') rct(x + (bx + c) * PX, y + r * PX, PX, PX, ink);
    bx += gw + 1;
  }
}

// Inverted tag, L7 style: ink box, cut corners, black text; 18 px tall.
static int tagI(int x, int y, const char *s, uint16_t bg = INK, uint16_t ink = BG) {
  int w = txtW(s) + 8, h = 18;
  rct(x, y, w, h, bg);
  rct(x, y, PX, PX, BG); rct(x + w - PX, y, PX, PX, BG);
  rct(x, y + h - PX, PX, PX, BG); rct(x + w - PX, y + h - PX, PX, PX, BG);
  txt(x + (w - txtW(s)) / 2, y + 4, s, ink);
  return w;
}

